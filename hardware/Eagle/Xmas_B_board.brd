# Repository kaz19610303/LED_Christmas_tree

File README.md:

# LED_Christmas_tree DIY kit

3mm LED 36個と5mm LED1個を使った、LEDクリスマスツリー DIY キットです。  
ご自身でハンダ付けする必要があります。  
  
回路図と基板データを登録していますのでそれを基にオリジナルのクリスマスツリーをお作り下さい。  
現在 Eagle用のデータのみ登録
KiKADデータは準備中 
ドキュメントページはただ今準備中です。

このDIYキットはこちらのページで販売予定です。
https://nextstep.official.ec/  
  
この基板の作成には [JLCPCB](https://jlcpcb.com/HAR) 様の支援を受けています。  
なお現在 JLCPCB は**新規登録で$54クーポン進呈キャンペーン継続中**です。

## EAGLE design hardware/Eagle/Xmas_B_board.brd

Parts:
C1, C2, C3: 47uF; E2-4
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14, LED15, LED16, LED17, LED18: LED3MM
R1, R3, R5: 1k; 0204/7
R2, R4, R6: 100; 0204/7
TR1, TR2, TR3: 2SC1815; TO92-ECB
U$1, U$2: XMAS_POWER

Connections:
GND: TR1.E, TR2.E, TR3.E, U$2.P$1, U$2.P$2
unnamed: C3.-, R1.1, TR1.B
unnamed: LED1.K (C), LED2.K (C), LED3.K (C), LED4.K (C), LED5.K (C), LED6.K (C), R2.2
unnamed: C1.+, R2.1, TR1.C
unnamed: LED7.K (C), LED8.K (C), LED9.K (C), LED10.K (C), LED11.K (C), LED12.K (C), R4.2
unnamed: C2.+, R4.1, TR2.C
unnamed: C1.-, R3.1, TR2.B
unnamed: C3.+, R6.1, TR3.C
unnamed: C2.-, R5.1, TR3.B
unnamed: LED13.K (C), LED14.K (C), LED15.K (C), LED16.K (C), LED17.K (C), LED18.K (C), R6.2
VCC: LED1.A, LED2.A, LED3.A, LED4.A, LED5.A, LED6.A, LED7.A, LED8.A, LED9.A, LED10.A, LED11.A, LED12.A, LED13.A, LED14.A, LED15.A, LED16.A, LED17.A, LED18.A, R1.2, R3.2, R5.2, U$1.P$1, U$1.P$2

Notes on the sheet:
LED1 ～ LED18 ＲＧＢイルミネーションフルカラーＬＥＤ 3mm
LED Christmas tree 基板 B NS-DIY-1001
Next Step LLC

Board: 2 copper layers, 60.0 x 118.9 mm, 32 parts (0 on the bottom side), 11 nets.

## EAGLE design hardware/Eagle/Xmas_base_board.brd

Parts:
CN1: MRUSB-2B-D14NI-S306_MRUSB-2B
J1: DCJ0303
J2: CONN_02; 1X02
SW1: SWITCH-SPDT-PTH-11.6X4.0MM; SWITCH_SPDT_PTH_11.6X4.0MM
U$5, U$6, U$7, U$8: XMAS-TREE

Connections:
GND: CN1.2, CN1.3, CN1.4, J1.2, J1.3, J2.2, U$7.P$1, U$7.P$2, U$8.P$1, U$8.P$2
unnamed: CN1.1, J1.1, J2.1, SW1.2
unnamed: SW1.1 (O), U$5.P$1, U$5.P$2, U$6.P$1, U$6.P$2

Notes on the sheet:
LED Christmas tree 基板 C(台座) NS-DIY-1001
Next Step LLC

Board: 2 copper layers, 58.5 x 58.5 mm, 12 parts (0 on the bottom side), 3 nets.

Other parts of the board:
U$1, U$2, U$3, U$4: 3,2

## Commit log

2022-11-03 Eagle data upload
2022-11-05 garber data upload
2022-11-05 抵抗の定数変更
2022-12-01 assembly_instructions 追加
2022-12-01 assembly_instructions upload
2022-12-02 assembly_instructions 加筆

Notices in the files:
parts and their libraries:
SparkFun-Connectors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
